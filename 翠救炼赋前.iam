# Autodesk Inventor assembly: 답안조립품
## iProperties
Created: 2014-12
Part Number: 답안조립품
Document SubType Name: Assembly
Designer: elite
Author: elite
